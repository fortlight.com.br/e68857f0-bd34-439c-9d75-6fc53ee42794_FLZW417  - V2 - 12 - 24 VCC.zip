Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: I:\A - PROJETO NOVO WORKSPACE\ENGENHARIA LUMINARIA\A - PROJETOS & DESENVOLVIMENTO\FLZW 41 - V2\EM ANDAMENTO\DESENHOS\MONTAGEM\FLZW 417 - ARANDELA 90°\PARA ENVIO\FLZW 417 - V2.IFC
Time: 2024-11-06T16:43:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
